<?xml version="1.0" encoding="UTF-8"?>
<workspace>
    <project>
        <path>$WS_DIR$\MDR1986VEx+FreeRTOS-Plus-TCP.ewp</path>
    </project>
    <batchBuild />
</workspace>
