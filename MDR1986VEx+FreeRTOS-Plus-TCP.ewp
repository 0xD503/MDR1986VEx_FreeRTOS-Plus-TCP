# IAR project MDR1986VEx+FreeRTOS-Plus-TCP.ewp, settings and files
configuration Debug (ARM, debug)
  General.OGChipSelectEditMenu: MDR1986VE3 Milandr MDR1986VE3
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  General.CoreVariant: 36
  General.FPU2: 0
  ICCARM.CCIncludePath2: MDR32F9Qx_SPL\inc\; CMSIS\Core\Include\; CMSIS\Device\inc\; CMSIS\Device\startup\iar\; FreeRTOS-Kernel\include\; FreeRTOS-Kernel\portable\IAR\ARM_CM0\; config\; FreeRTOS-Plus-TCP\include\; FreeRTOS-Plus-TCP\portable\Compiler\IAR\; FreeRTOS-Plus-TCP\portable\NetworkInterface\include\; include\; include\board\
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  AARM.AUserIncludes: config\; include\; CMSIS\Device\startup\iar\; FreeRTOS-Kernel\portable\IAR\ARM_CM0\
  OBJCOPY.OOCOutputFile: MDR1986VEx+FreeRTOS-Plus-TCP.hex
  ILINK.IlinkOutputFile: $PROJ_FNAME$.out
  ILINK.IlinkIcfFile: config\MDR1986VE3.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Release (ARM)
  as the first configuration, except:
  General.CoreVariant: 38
  ICCARM.CCDefines: NDEBUG
  ICCARM.CCOptLevel: 3
  group (top)
    src/: app.c app_tasks.c bsp.c main.c prng.c tcpip_api.c utils.c
  group board
    src/board/: clock.c eth_mac_driver.c ports.c
  group CMSIS/Device/startup
    CMSIS/Device/startup/iar/: startup_MDR1986VE3.s system_MDR1986VE3.c
  group config
    config/: MDR1986VE3.icf
  group FreeRTOS
    FreeRTOS-Kernel/: event_groups.c list.c queue.c tasks.c timers.c
  group FreeRTOS/portable
    FreeRTOS-Kernel/portable/IAR/ARM_CM0/: port.c portasm.s
  group FreeRTOS/portable/MemMang
    FreeRTOS-Kernel/portable/MemMang/: heap_4.c
  group FreeRTOS-Plus-TCP
    FreeRTOS-Plus-TCP/: FreeRTOS_ARP.c FreeRTOS_DHCP.c FreeRTOS_DNS.c FreeRTOS_IP.c FreeRTOS_Sockets.c FreeRTOS_Stream_Buffer.c FreeRTOS_TCP_IP.c FreeRTOS_TCP_WIN.c FreeRTOS_UDP_IP.c
  group FreeRTOS-Plus-TCP/portable/BufferManagement
    FreeRTOS-Plus-TCP/portable/BufferManagement/: BufferAllocation_2.c
  group FreeRTOS-Plus-TCP/portable/NetworkInterface
    FreeRTOS-Plus-TCP/portable/NetworkInterface/MDR1986VE3/: NetworkInterface.c
  group FreeRTOS-Plus-TCP/portable/NetworkInterface/common
    FreeRTOS-Plus-TCP/portable/NetworkInterface/Common/: phyHandling.c
  group SPL
    MDR32F9Qx_SPL/src/: MDR32F9Qx_dma.c MDR32F9Qx_eeprom.c MDR32F9Qx_eth.c MDR32F9Qx_port.c MDR32F9Qx_power.c MDR32F9Qx_rst_clk.c MDR32F9Qx_timer.c
